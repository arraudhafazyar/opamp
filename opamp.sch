v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {nmoscs.sym} -30 -40 0 0 {name=x1}
C {nmoscs2.sym} 330 -50 0 0 {name=x2}
C {pmoscs.sym} -60 -200 0 0 {name=x3}
C {differential.sym} 340 -200 0 0 {name=x4}
C {devices/iopin.sym} -430 -210 0 0 {name=p2 lab=VDD}
C {devices/iopin.sym} -430 -180 2 1 {name=p6 lab=GND}
C {devices/opin.sym} -430 -150 0 0 {name=p3 lab=OUT}
C {devices/iopin.sym} -430 -120 2 1 {name=p4 lab=RS}
C {devices/ipin.sym} -430 -80 0 1 {name=p5 lab=VPIN}
C {devices/ipin.sym} -430 -40 2 0 {name=p1 lab=VIN}
C {devices/lab_pin.sym} 90 -230 2 0 {name=p7 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 90 -210 2 0 {name=p8 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 90 -190 2 0 {name=p9 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 90 -170 2 0 {name=p10 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 120 -70 2 0 {name=p11 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 120 -50 2 0 {name=p12 sig_type=std_logic lab=net1

}
C {devices/lab_pin.sym} 120 -30 2 0 {name=p13 sig_type=std_logic lab=RS}
C {devices/lab_pin.sym} 120 -10 2 0 {name=p14 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 490 -230 2 0 {name=p15 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 490 -210 2 0 {name=p16 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 490 -190 2 0 {name=p17 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 490 -170 2 0 {name=p18 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 480 -70 2 0 {name=p19 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 480 -50 2 0 {name=p20 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} 480 -30 2 0 {name=p21 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 190 -230 2 1 {name=p22 sig_type=std_logic lab=VPIN}
C {devices/lab_pin.sym} 190 -210 2 1 {name=p23 sig_type=std_logic lab=VIN}
